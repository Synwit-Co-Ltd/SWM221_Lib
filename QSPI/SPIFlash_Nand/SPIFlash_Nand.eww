<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SPIFlash_Nand.ewp</path>
  </project>
  <batchBuild/>
</workspace>
