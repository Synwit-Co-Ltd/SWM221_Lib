# IAR project FreeRTOS.ewp, settings and files
configuration SWM221 (ARM, debug)
  General.OGChipSelectEditMenu: SWM221xB Synwit SWM221xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM221
  ICCARM.CCIncludePath2: ..\..\SWM221_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM221_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM221_StdPeriph_Driver\CSL\SWM221_StdPeriph_Driver; .\APP; .\APP\FreeRTOS\include; .\APP\FreeRTOS\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM221
  AARM.AUserIncludes: .\APP
  OBJCOPY.OOCOutputFile: FreeRTOS.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/IAR/ARM_CM0/: portasm.s port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM221_StdPeriph_Driver/CSL/SWM221_StdPeriph_Driver/: SWM221_adc.c SWM221_exti.c SWM221_gpio.c SWM221_i2c.c SWM221_pwm.c SWM221_timr.c SWM221_uart.c SWM221_wdt.c SWM221_port.c SWM221_flash.c
  group CSL\CMSIS
    ../../SWM221_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM221.c
    ../../SWM221_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM221.s
