# Keil uVision project SimplDMA_EXHS.uvprojx, settings and files
target SWM221 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM221x8 Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SimplDMA_EXHS
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=1
  c define: CHIP_SWM221
  c include: ..\..\SWM221_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM221_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM221_StdPeriph_Driver\CSL\SWM221_StdPeriph_Driver
  asm define: CHIP_SWM221
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM221_StdPeriph_Driver/CSL/SWM221_StdPeriph_Driver/: SWM221_adc.c SWM221_exti.c SWM221_gpio.c SWM221_i2c.c SWM221_pwm.c SWM221_timr.c SWM221_uart.c SWM221_wdt.c SWM221_port.c SWM221_can.c SWM221_cordic.c SWM221_div.c SWM221_dma.c SWM221_qei.c SWM221_sleep.c SWM221_spi.c SWM221_flash.c
  group CSL\CMSIS
    ../../SWM221_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM221.c
    ../../SWM221_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM221.s
