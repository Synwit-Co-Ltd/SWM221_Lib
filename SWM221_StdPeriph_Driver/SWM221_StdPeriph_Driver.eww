<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SWM221_StdPeriph_Driver.ewp</path>
  </project>
  <batchBuild/>
</workspace>
