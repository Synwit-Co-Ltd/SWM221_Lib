# IAR project SWM221_StdPeriph_Driver.ewp, settings and files
configuration SWM221 (ARM, debug)
  General.OGChipSelectEditMenu: SWM221xB Synwit SWM221xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM221
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM221_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM221
  OBJCOPY.OOCOutputFile: SWM221_StdPeriph_Driver.bin
  ILINK.IlinkOutputFile: SWM221_StdPeriph_Driver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    APP/: main.c
  group CSL\CMSIS
    CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM221.s
    CSL/CMSIS/DeviceSupport/: system_SWM221.c
  group CSL\StdPD
    CSL/SWM221_StdPeriph_Driver/: SWM221_adc.c SWM221_can.c SWM221_crc.c SWM221_div.c SWM221_dma.c SWM221_exti.c SWM221_flash.c SWM221_gpio.c SWM221_i2c.c SWM221_iofilt.c SWM221_mpu.c SWM221_port.c SWM221_pwm.c SWM221_qei.c SWM221_qspi.c SWM221_spi.c SWM221_timr.c SWM221_uart.c SWM221_usart.c SWM221_wdt.c
