<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimplADC0_CMP.ewp</path>
  </project>
  <batchBuild/>
</workspace>
