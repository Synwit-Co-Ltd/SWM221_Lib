<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimplLIN_Slave.ewp</path>
  </project>
  <batchBuild/>
</workspace>
